# IAR project project.ewp, settings and files
configuration STM8L15X_HD(STM8L15xx8_16xx8) (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152R8 STM8L152R8
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x500
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L15X_HD; USR_ERROR_CHECK
  ICCSTM8.CCIncludePath2: ..\source\usr\inc; ..\source\lib\inc; ..\source\os; ..\source\driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group driver
    ../Source/driver/src/: crc.c sle4442.c
  group OS
    ../Source/os/: app_scheduler.c
  group STM8L15x_StdPeriph_Driver
    ../Source/lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Usr
    ../Source/usr/src/: app_trace.c beeper.c delay.c flash.c ic.c led.c main.c stm8l15x_it.c
